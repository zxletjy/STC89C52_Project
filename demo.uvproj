# Keil uVision project demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: demo +hex
  c flags: Optimize=8
  c include: .\Serial;.\SoftwareSPI;.\nRF24l01
  group Source Group 1
    ./: main.c
    ./Serial/: Serial.c
    ./SoftwareSPI/: spi.c
    ./nRF24l01/: nRF24L01.c
